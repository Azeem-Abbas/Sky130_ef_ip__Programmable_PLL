v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 850 -610 850 -540 {
lab=VDD}
N 780 -610 850 -610 {
lab=VDD}
N 850 -420 850 -380 {
lab=VSS}
N 630 -490 700 -490 {
lab=VCTRL_OBV}
N 590 -470 700 -470 {
lab=VDD}
N 70 -640 70 -610 {
lab=VDD}
N 70 -480 70 -450 {
lab=VSS}
N 110 -670 110 -610 {
lab=ITAIL_SRC}
N 90 -670 90 -610 {
lab=ITAIL_SINK}
N -480 -680 -480 -650 {
lab=VDD}
N -480 -540 -480 -510 {
lab=VSS}
N 1000 -500 1150 -500 {
lab=OUTA1}
N -360 -910 -320 -910 {
lab=UP1}
N -350 -890 -320 -890 {
lab=UP_INPUT}
N -360 -890 -350 -890 {
lab=UP_INPUT}
N -360 -870 -320 -870 {
lab=S2}
N -170 -980 -170 -940 {
lab=VDD}
N -170 -840 -170 -810 {
lab=VSS}
N -200 -440 -200 -410 {
lab=VDD}
N -360 -380 -340 -380 {
lab=DN1}
N -350 -360 -340 -360 {
lab=DN_INPUT}
N -360 -340 -340 -340 {
lab=S3}
N -50 -360 -20 -360 {
lab=DN}
N -200 -310 -200 -290 {
lab=VSS}
N -1060 -770 -1020 -770 {
lab=pre_out}
N -1050 -750 -1020 -750 {
lab=F_IN}
N -1060 -750 -1050 -750 {
lab=F_IN}
N -1060 -730 -1020 -730 {
lab=S1}
N -870 -840 -870 -800 {
lab=VDD}
N -870 -700 -870 -670 {
lab=VSS}
N -1090 -440 -1050 -440 {
lab=OUT01}
N -1080 -420 -1050 -420 {
lab=VSS}
N -1090 -420 -1080 -420 {
lab=VSS}
N -1090 -400 -1050 -400 {
lab=S6}
N -900 -510 -900 -470 {
lab=VDD}
N -900 -370 -900 -340 {
lab=VSS}
N 290 -680 360 -680 {
lab=MUFTA2}
N 630 -580 630 -490 {
lab=VCTRL_OBV}
N 630 -580 700 -580 {
lab=VCTRL_OBV}
N 700 -660 700 -580 {
lab=VCTRL_OBV}
N 360 -680 370 -680 {
lab=MUFTA2}
N 670 -660 700 -660 {
lab=VCTRL_OBV}
N 520 -720 520 -710 {
lab=VDD}
N 520 -610 520 -590 {
lab=VSS}
N 350 -660 370 -660 {
lab=VCTRL_IN}
N 340 -640 370 -640 {
lab=S4}
N -100 -560 -80 -560 {
lab=UP}
N -710 -760 -710 -610 {
lab=FIN}
N -700 -590 -700 -430 {
lab=FDIV}
N -110 -580 -80 -580 {
lab=DN}
N -720 -770 -720 -750 {
lab=FIN}
N -720 -770 -710 -770 {
lab=FIN}
N -710 -770 -710 -760 {
lab=FIN}
N -700 -430 -700 -420 {
lab=FDIV}
N -750 -420 -700 -420 {
lab=FDIV}
N -100 -790 -100 -560 {
lab=UP}
N -100 -790 0 -790 {
lab=UP}
N 0 -890 0 -790 {
lab=UP}
N -20 -890 0 -890 {
lab=UP}
N -0 -910 0 -890 {
lab=UP}
N 0 -910 20 -910 {
lab=UP}
N -110 -580 -110 -410 {
lab=DN}
N -110 -410 -50 -410 {
lab=DN}
N -50 -410 -50 -360 {
lab=DN}
N 370 -310 370 -290 {
lab=VDD}
N 370 -190 370 -160 {
lab=VSS}
N 220 -520 530 -520 {
lab=MUFTA2}
N 530 -520 530 -240 {
lab=MUFTA2}
N 520 -240 530 -240 {
lab=MUFTA2}
N 150 -220 220 -220 {
lab=S5}
N 110 -240 220 -240 {
lab=LF_OFFCHIP}
N 290 -680 290 -520 {
lab=MUFTA2}
N 1150 -500 1270 -500 {
lab=OUTA1}
N 1270 -600 1270 -500 {
lab=OUTA1}
N 1270 -600 1330 -600 {
lab=OUTA1}
N 1330 -470 1330 -390 {
lab=OUTA2}
N 1330 -390 1340 -390 {
lab=OUTA2}
N 1520 -600 1560 -600 {
lab=OUT}
N 1530 -390 1570 -390 {
lab=OUTB}
N 1410 -690 1410 -670 {
lab=VDD_TEST}
N 1420 -520 1420 -510 {
lab=VSS}
N 1420 -490 1420 -460 {
lab=VDD_TEST}
N 1430 -310 1430 -290 {
lab=VSS}
N -420 -380 -360 -380 {
lab=DN1}
N -370 -360 -350 -360 {
lab=DN_INPUT}
N -430 -910 -430 -890 {
lab=UP1}
N -430 -910 -360 -910 {
lab=UP1}
N 1150 -130 1150 -80 {
lab=OUT_D}
N 1220 -240 1260 -240 {
lab=VDD_TEST}
N 1050 -230 1070 -230 {
lab=VSS}
N 810 20 810 60 {
lab=VDD}
N 810 340 810 350 {
lab=VSS}
N 690 120 710 120 {
lab=D6}
N 670 140 710 140 {
lab=D5}
N 660 160 710 160 {
lab=D4}
N 650 180 710 180 {
lab=D3}
N 630 200 710 200 {
lab=D2}
N 600 220 710 220 {
lab=D1}
N 570 240 710 240 {
lab=D0}
N 540 260 710 260 {
lab=IN_DIV}
N 560 240 570 240 {
lab=D0}
N -1440 -800 -1440 -760 {
lab=VDD}
N -1440 -480 -1440 -470 {
lab=VSS}
N -1590 -660 -1540 -660 {
lab=VSS}
N -1600 -640 -1540 -640 {
lab=D10}
N -1620 -620 -1540 -620 {
lab=D9}
N -1650 -600 -1540 -600 {
lab=D8}
N -1680 -580 -1540 -580 {
lab=D7}
N -1710 -560 -1540 -560 {
lab=F_IN}
N -1690 -580 -1680 -580 {
lab=D7}
N -1320 -530 -1120 -530 {
lab=pre_out}
N -1120 -770 -1120 -530 {
lab=pre_out}
N -1120 -770 -1060 -770 {
lab=pre_out}
N 1900 30 1900 70 {
lab=VDD}
N 1900 350 1900 360 {
lab=VSS}
N 1780 130 1800 130 {
lab=GND}
N 1740 190 1800 190 {
lab=D15}
N 1720 210 1800 210 {
lab=D14}
N 1690 230 1800 230 {
lab=D13}
N 1660 250 1800 250 {
lab=D12}
N 1630 270 1800 270 {
lab=OUT}
N 2000 300 2020 300 {
lab=OUT11}
N 1650 250 1660 250 {
lab=D12}
N 2020 300 2160 300 {
lab=OUT11}
N 2620 300 2660 300 {
lab=OUT_CORE}
N 2510 190 2510 230 {
lab=VDD_TEST}
N 2520 380 2520 410 {
lab=VSS}
N -1120 -970 -1120 -960 {
lab=PRE_SCALAR}
N -1230 -850 -1190 -850 {
lab=VDD_TEST}
N -1040 -860 -1010 -860 {
lab=VSS}
N 50 -300 190 -300 {
lab=MUFTA}
N 50 -300 50 -120 {
lab=MUFTA}
N 50 -120 60 -120 {
lab=MUFTA}
N -170 30 -170 80 {
lab=DN_OUT}
N -100 -80 -60 -80 {
lab=VDD_TEST}
N -270 -70 -250 -70 {
lab=VSS}
N 970 290 970 360 {
lab=OUT01}
N 970 550 970 600 {
lab=DIV_OUT}
N 1040 440 1080 440 {
lab=VDD_TEST}
N 870 450 890 450 {
lab=VSS}
N -120 -1280 -120 -1270 {
lab=UP_OUT}
N -230 -1160 -190 -1160 {
lab=VDD_TEST}
N -40 -1170 -10 -1170 {
lab=VSS}
N -40 400 120 400 {
lab=F_IN}
N -130 420 120 420 {
lab=S7}
N 420 400 530 400 {
lab=IN_DIV}
N 530 260 530 400 {
lab=IN_DIV}
N 530 260 540 260 {
lab=IN_DIV}
N 270 310 270 350 {
lab=VDD}
N 270 450 270 490 {
lab=VSS}
N -1340 -530 -1320 -530 {
lab=pre_out}
N 700 -660 740 -660 {
lab=VCTRL_OBV}
N -1340 -710 -1290 -710 {
lab=P22}
N -1340 -690 -1270 -690 {
lab=LD2}
N -1340 -670 -1250 -670 {
lab=Q21}
N -1340 -650 -1230 -650 {
lab=Q22}
N -1340 -630 -1210 -630 {
lab=Q23}
N -1340 -610 -1190 -610 {
lab=Q24}
N -1340 -590 -1170 -590 {
lab=Q25}
N -1340 -570 -1150 -570 {
lab=Q26}
N -1340 -550 -1130 -550 {
lab=Q27}
N -1240 -850 -1230 -850 {
lab=VDD_TEST}
N 2020 120 2040 120 {
lab=P12}
N 2020 140 2040 140 {
lab=LD1}
N 2020 160 2040 160 {
lab=Q11}
N 2020 180 2040 180 {
lab=Q12}
N 2020 200 2040 200 {
lab=Q13}
N 2020 240 2040 240 {
lab=Q15}
N 2020 260 2040 260 {
lab=Q16}
N 2000 120 2020 120 {
lab=P12}
N 2000 140 2020 140 {
lab=LD1}
N 2000 160 2010 160 {
lab=Q11}
N 2000 180 2020 180 {
lab=Q12}
N 2000 200 2020 200 {
lab=Q13}
N 2000 220 2010 220 {
lab=Q14}
N 2000 240 2020 240 {
lab=Q15}
N 2000 260 2020 260 {
lab=Q16}
N 2000 280 2020 280 {
lab=Q17}
N 2040 120 2090 120 {
lab=P12}
N 2040 140 2110 140 {
lab=LD1}
N 2040 160 2130 160 {
lab=Q11}
N 2040 180 2150 180 {
lab=Q12}
N 2040 200 2170 200 {
lab=Q13}
N 2040 220 2190 220 {
lab=Q14}
N 2040 240 2210 240 {
lab=Q15}
N 2040 260 2230 260 {
lab=Q16}
N 2040 280 2250 280 {
lab=Q17}
N 2020 280 2040 280 {
lab=Q17}
N 2020 220 2040 220 {
lab=Q14}
N 2010 220 2020 220 {
lab=Q14}
N 2010 160 2020 160 {
lab=Q11}
N 910 290 930 290 {
lab=OUT01}
N 930 290 1070 290 {
lab=OUT01}
N 930 110 950 110 {
lab=P02}
N 930 130 950 130 {
lab=LD0}
N 930 150 950 150 {
lab=Q01}
N 930 170 950 170 {
lab=Q02}
N 930 190 950 190 {
lab=Q03}
N 930 230 950 230 {
lab=Q05}
N 930 250 950 250 {
lab=Q06}
N 910 110 930 110 {
lab=P02}
N 910 130 930 130 {
lab=LD0}
N 910 150 920 150 {
lab=Q01}
N 910 170 930 170 {
lab=Q02}
N 910 190 930 190 {
lab=Q03}
N 910 210 920 210 {
lab=Q04}
N 910 230 930 230 {
lab=Q05}
N 910 250 930 250 {
lab=Q06}
N 910 270 930 270 {
lab=Q07}
N 950 110 1000 110 {
lab=P02}
N 950 130 1020 130 {
lab=LD0}
N 950 150 1040 150 {
lab=Q01}
N 950 170 1060 170 {
lab=Q02}
N 950 190 1080 190 {
lab=Q03}
N 950 210 1100 210 {
lab=Q04}
N 950 230 1120 230 {
lab=Q05}
N 950 250 1140 250 {
lab=Q06}
N 950 270 1160 270 {
lab=Q07}
N 930 270 950 270 {
lab=Q07}
N 930 210 950 210 {
lab=Q04}
N 920 210 930 210 {
lab=Q04}
N 920 150 930 150 {
lab=Q01}
N 1070 290 1170 290 {
lab=OUT01}
N 2160 300 2430 300 {
lab=OUT11}
N -100 -80 -100 -70 {
lab=VDD_TEST}
N -250 -70 -250 -60 {
lab=VSS}
N 90 380 120 380 {
lab=OUT_D}
N -1150 -420 -1090 -420 {
lab=VSS}
N 1000 -470 1330 -470 {
lab=OUTA2}
N 1150 -470 1150 -320 {
lab=OUTA2}
N -90 -940 20 -940 {
lab=UP}
N 20 -940 20 -910 {
lab=UP}
N -90 -1080 -90 -1040 {
lab=UP}
N -120 -1080 -90 -1080 {
lab=UP}
N -20 -360 -20 -250 {
lab=DN}
N -170 -250 -20 -250 {
lab=DN}
N -250 -290 -250 -200 {
lab=VSS}
N -250 -290 -200 -290 {
lab=VSS}
N 60 -120 160 -120 {
lab=MUFTA}
N 190 -300 190 -260 {
lab=MUFTA}
N 190 -260 220 -260 {
lab=MUFTA}
N -430 -890 -430 -680 {
lab=UP1}
N -430 -680 -330 -680 {
lab=UP1}
N -330 -680 -330 -610 {
lab=UP1}
N -420 -480 -420 -380 {
lab=DN1}
N -420 -480 -330 -480 {
lab=DN1}
N -330 -590 -330 -480 {
lab=DN1}
N -710 -610 -710 -580 {
lab=FIN}
N -710 -580 -630 -580 {
lab=FIN}
N -630 -590 -630 -580 {
lab=FIN}
N -700 -610 -700 -590 {
lab=FDIV}
N -700 -610 -630 -610 {
lab=FDIV}
N -90 -1040 -90 -940 {
lab=UP}
N -170 -250 -170 -150 {
lab=DN}
N 70 -670 90 -670 {
lab=ITAIL_SINK}
N 110 -690 110 -670 {
lab=ITAIL_SRC}
N 110 -700 110 -690 {
lab=ITAIL_SRC}
N 1530 -1110 1530 -1070 {
lab=VDD}
N 1530 -790 1530 -780 {
lab=VSS}
N 1370 -950 1430 -950 {
lab=D19}
N 1350 -930 1430 -930 {
lab=D18}
N 1320 -910 1430 -910 {
lab=D17}
N 1290 -890 1430 -890 {
lab=D16}
N 1260 -870 1430 -870 {
lab=OUTB}
N 1630 -840 1650 -840 {
lab=#net1}
N 1280 -890 1290 -890 {
lab=D16}
N 1650 -840 1790 -840 {
lab=#net1}
N 2140 -950 2140 -910 {
lab=VDD_TEST}
N 2150 -760 2150 -730 {
lab=VSS}
N 1650 -1020 1670 -1020 {
lab=p2u}
N 1650 -1000 1670 -1000 {
lab=LD1u}
N 1650 -980 1670 -980 {
lab=Q11u}
N 1650 -960 1670 -960 {
lab=Q12u}
N 1650 -940 1670 -940 {
lab=Q13u}
N 1650 -900 1670 -900 {
lab=Q15u}
N 1650 -880 1670 -880 {
lab=Q16u}
N 1630 -1020 1650 -1020 {
lab=p2u}
N 1630 -1000 1650 -1000 {
lab=LD1u}
N 1630 -980 1640 -980 {
lab=Q11u}
N 1630 -960 1650 -960 {
lab=Q12u}
N 1630 -940 1650 -940 {
lab=Q13u}
N 1630 -920 1640 -920 {
lab=Q14u}
N 1630 -900 1650 -900 {
lab=Q15u}
N 1630 -880 1650 -880 {
lab=Q16u}
N 1630 -860 1650 -860 {
lab=Q17u}
N 1670 -1020 1720 -1020 {
lab=p2u}
N 1670 -1000 1740 -1000 {
lab=LD1u}
N 1670 -980 1760 -980 {
lab=Q11u}
N 1670 -960 1780 -960 {
lab=Q12u}
N 1670 -940 1800 -940 {
lab=Q13u}
N 1670 -920 1820 -920 {
lab=Q14u}
N 1670 -900 1840 -900 {
lab=Q15u}
N 1670 -880 1860 -880 {
lab=Q16u}
N 1670 -860 1880 -860 {
lab=Q17u}
N 1650 -860 1670 -860 {
lab=Q17u}
N 1650 -920 1670 -920 {
lab=Q14u}
N 1640 -920 1650 -920 {
lab=Q14u}
N 1640 -980 1650 -980 {
lab=Q11u}
N 1790 -840 2060 -840 {
lab=#net1}
N -1540 -700 -1540 -680 {
lab=VSS}
N 1770 150 1800 150 {
lab=GND}
N 1770 170 1800 170 {
lab=GND}
N 1410 -1010 1430 -1010 {
lab=GND}
N 1420 -990 1430 -990 {
lab=GND}
N 1410 -970 1430 -970 {
lab=GND}
N 2250 -840 2290 -840 {
lab=OUT_USB}
N 70 -700 70 -670 {
lab=ITAIL_SINK}
N 70 -700 90 -700 {
lab=ITAIL_SINK}
N 20 -850 40 -850 {
lab=VSS}
N 160 -850 180 -850 {
lab=VDD}
N 130 -1020 130 -1000 {
lab=ITAIL}
N 340 50 450 50 {
lab=GND}
N 520 30 520 50 {
lab=GND}
N 340 -100 340 -10 {
lab=MUFTA}
N 340 -100 450 -100 {
lab=MUFTA}
N 520 -100 520 -90 {
lab=MUFTA}
N 160 -120 350 -120 {
lab=MUFTA}
N 350 -120 350 -100 {
lab=MUFTA}
N 480 -60 500 -60 {
lab=GND}
N 480 -60 480 50 {
lab=GND}
N 450 50 520 50 {
lab=GND}
N 450 -100 520 -100 {
lab=MUFTA}
N 510 50 510 60 {
lab=GND}
N -1590 -690 -1590 -660 {
lab=VSS}
N -1590 -690 -1540 -690 {
lab=VSS}
C {devices/lab_wire.sym} 780 -610 0 0 {name=p2 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 590 -470 0 0 {name=p11 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 70 -450 0 0 {name=p25 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 70 -630 0 0 {name=p27 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} -480 -680 0 0 {name=p31 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} -480 -520 0 0 {name=p32 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} -170 -980 0 0 {name=p22 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} -200 -440 0 0 {name=p23 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} -170 -810 0 0 {name=p24 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} -200 -290 0 0 {name=p26 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} -360 -340 0 0 {name=p37 sig_type=std_logic lab=S3}
C {devices/lab_wire.sym} -20 -360 1 0 {name=p49 sig_type=std_logic lab=DN}
C {devices/lab_wire.sym} -360 -890 0 0 {name=p54 sig_type=std_logic lab=UP_INPUT}
C {devices/lab_wire.sym} 850 -390 0 0 {name=p7 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} -870 -840 0 0 {name=p1 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} -1060 -730 0 0 {name=p3 sig_type=std_logic lab=S1}
C {devices/lab_wire.sym} -1710 -560 0 0 {name=p4 sig_type=std_logic lab=F_IN}
C {devices/lab_wire.sym} -1060 -750 0 0 {name=p6 sig_type=std_logic lab=F_IN}
C {devices/lab_wire.sym} -900 -510 0 0 {name=p8 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} -1090 -400 0 0 {name=p9 sig_type=std_logic lab=S6}
C {devices/lab_wire.sym} -870 -670 0 0 {name=p39 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} -900 -340 0 0 {name=p40 sig_type=std_logic lab=VSS}
C {devices/ipin.sym} 800 -1180 0 0 {name=p10 lab=UP_INPUT}
C {devices/ipin.sym} 800 -1150 0 0 {name=p12 lab=DN_INPUT}
C {devices/opin.sym} 800 -1120 0 0 {name=p13 lab=UP_OUT}
C {devices/opin.sym} 800 -1090 0 0 {name=p14 lab=DN_OUT}
C {devices/ipin.sym} 800 -1060 0 0 {name=p15 lab=ITAIL}
C {devices/opin.sym} 800 -940 0 0 {name=p19 lab=OUT}
C {devices/iopin.sym} 800 -910 0 0 {name=p44 lab=OUTB}
C {devices/iopin.sym} 600 -1180 0 0 {name=p45 lab=VDD}
C {devices/iopin.sym} 600 -1150 0 0 {name=p46 lab=VSS}
C {devices/opin.sym} 600 -1120 0 0 {name=p47 lab=PRE_SCALAR}
C {devices/ipin.sym} 600 -1090 0 0 {name=p50 lab=F_IN}
C {devices/opin.sym} 600 -1060 0 0 {name=p51 lab=DIV_OUT}
C {devices/ipin.sym} 600 -1030 0 0 {name=p52 lab=S1}
C {devices/ipin.sym} 600 -1000 0 0 {name=p53 lab=S6}
C {devices/ipin.sym} 600 -970 0 0 {name=p56 lab=S2}
C {devices/ipin.sym} 600 -940 0 0 {name=p57 lab=S3}
C {devices/lab_wire.sym} 520 -720 0 0 {name=p17 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 520 -590 0 0 {name=p28 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 350 -660 0 0 {name=p33 sig_type=std_logic lab=VCTRL_IN}
C {devices/lab_wire.sym} 340 -640 0 0 {name=p34 sig_type=std_logic lab=S4}
C {devices/ipin.sym} 800 -1000 0 0 {name=p41 lab=VCTRL_IN}
C {devices/ipin.sym} 610 -910 0 0 {name=p58 lab=S4}
C {devices/lab_wire.sym} 370 -310 0 0 {name=p48 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 370 -160 0 0 {name=p62 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 160 -220 0 0 {name=p63 sig_type=std_logic lab=S5}
C {devices/lab_wire.sym} 110 -240 0 0 {name=p64 sig_type=std_logic lab=LF_OFFCHIP}
C {devices/ipin.sym} 610 -880 0 0 {name=p65 lab=S5}
C {devices/ipin.sym} 880 -880 0 0 {name=p66 lab=LF_OFFCHIP}
C {devices/lab_wire.sym} 1410 -690 0 0 {name=p20 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1420 -510 2 0 {name=p69 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1430 -290 2 0 {name=p70 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} -370 -360 0 0 {name=p71 sig_type=std_logic lab=DN_INPUT}
C {devices/lab_wire.sym} -360 -870 0 0 {name=p55 sig_type=std_logic lab=S2}
C {devices/lab_wire.sym} 1050 -230 3 0 {name=p43 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 690 120 0 0 {name=p73 sig_type=std_logic lab=D6}
C {devices/lab_pin.sym} 670 140 0 0 {name=p74 sig_type=std_logic lab=D5}
C {devices/lab_pin.sym} 660 160 0 0 {name=p75 sig_type=std_logic lab=D4}
C {devices/lab_pin.sym} 650 180 0 0 {name=p76 sig_type=std_logic lab=D3}
C {devices/lab_pin.sym} 630 200 0 0 {name=p77 sig_type=std_logic lab=D2}
C {devices/lab_pin.sym} 600 220 0 0 {name=p78 sig_type=std_logic lab=D1}
C {devices/lab_pin.sym} 560 240 0 0 {name=p79 sig_type=std_logic lab=D0}
C {devices/lab_wire.sym} 810 20 0 0 {name=p90 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 810 350 2 0 {name=p91 sig_type=std_logic lab=VSS}
C {devices/ipin.sym} 990 -1190 0 0 {name=p93 lab=D0}
C {devices/ipin.sym} 990 -1160 0 0 {name=p94 lab=D1}
C {devices/ipin.sym} 990 -1130 0 0 {name=p95 lab=D2}
C {devices/ipin.sym} 990 -1100 0 0 {name=p96 lab=D3}
C {devices/ipin.sym} 1000 -1070 0 0 {name=p97 lab=D4}
C {devices/ipin.sym} 1000 -1040 0 0 {name=p98 lab=D5}
C {devices/ipin.sym} 1000 -1000 0 0 {name=p99 lab=D6}
C {devices/ipin.sym} 1000 -970 0 0 {name=p100 lab=D7}
C {devices/ipin.sym} 1000 -940 0 0 {name=p101 lab=D8}
C {devices/ipin.sym} 1000 -910 0 0 {name=p102 lab=D9}
C {devices/ipin.sym} 1010 -880 0 0 {name=p103 lab=D10}
C {devices/ipin.sym} 1080 -1200 0 0 {name=p105 lab=D12}
C {devices/ipin.sym} 1080 -1170 0 0 {name=p106 lab=D13}
C {devices/ipin.sym} 1080 -1140 0 0 {name=p107 lab=D14}
C {devices/ipin.sym} 1080 -1110 0 0 {name=p108 lab=D15}
C {devices/ipin.sym} 1090 -1080 0 0 {name=p109 lab=D16}
C {devices/lab_pin.sym} -1600 -640 0 0 {name=p113 sig_type=std_logic lab=D10}
C {devices/lab_pin.sym} -1620 -620 0 0 {name=p114 sig_type=std_logic lab=D9}
C {devices/lab_pin.sym} -1650 -600 0 0 {name=p115 sig_type=std_logic lab=D8}
C {devices/lab_pin.sym} -1690 -580 0 0 {name=p116 sig_type=std_logic lab=D7}
C {devices/lab_wire.sym} -1440 -800 0 0 {name=p127 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} -1440 -470 2 0 {name=p128 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1740 190 0 0 {name=p133 sig_type=std_logic lab=D15}
C {devices/lab_pin.sym} 1720 210 0 0 {name=p134 sig_type=std_logic lab=D14}
C {devices/lab_pin.sym} 1690 230 0 0 {name=p135 sig_type=std_logic lab=D13}
C {devices/lab_pin.sym} 1650 250 0 0 {name=p136 sig_type=std_logic lab=D12}
C {devices/lab_pin.sym} 1630 270 0 0 {name=p137 sig_type=std_logic lab=OUT}
C {devices/lab_wire.sym} 1900 30 0 0 {name=p147 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1900 360 2 0 {name=p148 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2520 410 2 0 {name=p151 sig_type=std_logic lab=VSS}
C {devices/opin.sym} 800 -840 0 0 {name=p152 lab=OUT_USB}
C {devices/lab_wire.sym} -1010 -860 2 0 {name=p30 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} -270 -70 3 0 {name=p61 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -170 80 0 0 {name=p155 sig_type=std_logic lab=DN_OUT}
C {devices/lab_wire.sym} 870 450 3 0 {name=p156 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 970 600 0 0 {name=p158 sig_type=std_logic lab=DIV_OUT}
C {devices/lab_wire.sym} -120 -1280 0 0 {name=p89 sig_type=std_logic lab=UP_OUT}
C {devices/lab_wire.sym} -10 -1170 2 0 {name=p159 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 20 -910 2 0 {name=p160 sig_type=std_logic lab=UP}
C {devices/lab_wire.sym} -40 400 0 0 {name=p162 sig_type=std_logic lab=F_IN}
C {devices/lab_wire.sym} -130 420 0 0 {name=p163 sig_type=std_logic lab=S7}
C {devices/lab_wire.sym} 270 310 0 0 {name=p80 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 270 490 2 0 {name=p164 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 530 400 2 0 {name=p165 sig_type=std_logic lab=IN_DIV}
C {devices/ipin.sym} 620 -850 0 0 {name=p166 lab=S7}
C {devices/iopin.sym} 600 -1210 0 0 {name=p167 lab=VDD_TEST}
C {devices/lab_wire.sym} 1420 -490 0 0 {name=p68 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1260 -240 2 0 {name=p72 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2510 190 0 0 {name=p146 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1080 440 2 0 {name=p157 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} -60 -80 2 0 {name=p154 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} -220 -1160 0 0 {name=p153 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} -1230 -850 0 0 {name=p5 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 740 -660 2 0 {name=p81 sig_type=std_logic lab=VCTRL_OBV}
C {devices/lab_pin.sym} -1290 -710 2 0 {name=p83 sig_type=std_logic lab=P22}
C {devices/lab_pin.sym} -1270 -690 2 0 {name=p84 sig_type=std_logic lab=LD2}
C {devices/lab_pin.sym} -1260 -670 2 0 {name=p85 sig_type=std_logic lab=Q21}
C {devices/lab_pin.sym} -1240 -650 2 0 {name=p86 sig_type=std_logic lab=Q22}
C {devices/lab_pin.sym} -1210 -630 2 0 {name=p87 sig_type=std_logic lab=Q23}
C {devices/lab_pin.sym} -1200 -610 2 0 {name=p88 sig_type=std_logic lab=Q24}
C {devices/lab_pin.sym} -1170 -590 2 0 {name=p92 sig_type=std_logic lab=Q25}
C {devices/lab_pin.sym} -1160 -570 2 0 {name=p118 sig_type=std_logic lab=Q26}
C {devices/lab_pin.sym} -1130 -550 2 0 {name=p119 sig_type=std_logic lab=Q27}
C {devices/ipin.sym} 1020 -810 0 0 {name=p122 lab=D17}
C {devices/ipin.sym} 1020 -780 0 0 {name=p123 lab=D18}
C {devices/ipin.sym} 1020 -750 0 0 {name=p124 lab=D19}
C {devices/lab_pin.sym} 2090 120 2 0 {name=p129 sig_type=std_logic lab=P12}
C {devices/lab_pin.sym} 2110 140 2 0 {name=p130 sig_type=std_logic lab=LD1}
C {devices/lab_pin.sym} 2120 160 2 0 {name=p131 sig_type=std_logic lab=Q11}
C {devices/lab_pin.sym} 2140 180 2 0 {name=p138 sig_type=std_logic lab=Q12}
C {devices/lab_pin.sym} 2170 200 2 0 {name=p139 sig_type=std_logic lab=Q13}
C {devices/lab_pin.sym} 2180 220 2 0 {name=p140 sig_type=std_logic lab=Q14}
C {devices/lab_pin.sym} 2210 240 2 0 {name=p141 sig_type=std_logic lab=Q15}
C {devices/lab_pin.sym} 2220 260 2 0 {name=p142 sig_type=std_logic lab=Q16}
C {devices/lab_pin.sym} 2250 280 2 0 {name=p143 sig_type=std_logic lab=Q17}
C {devices/lab_pin.sym} 2300 300 3 0 {name=p144 sig_type=std_logic lab=OUT11}
C {devices/lab_pin.sym} 1000 110 2 0 {name=p145 sig_type=std_logic lab=P02}
C {devices/lab_pin.sym} 1020 130 2 0 {name=p149 sig_type=std_logic lab=LD0}
C {devices/lab_pin.sym} 1030 150 2 0 {name=p168 sig_type=std_logic lab=Q01}
C {devices/lab_pin.sym} 1050 170 2 0 {name=p169 sig_type=std_logic lab=Q02}
C {devices/lab_pin.sym} 1080 190 2 0 {name=p170 sig_type=std_logic lab=Q03}
C {devices/lab_pin.sym} 1090 210 2 0 {name=p171 sig_type=std_logic lab=Q04}
C {devices/lab_pin.sym} 1120 230 2 0 {name=p172 sig_type=std_logic lab=Q05}
C {devices/lab_pin.sym} 1130 250 2 0 {name=p173 sig_type=std_logic lab=Q06}
C {devices/lab_pin.sym} 1160 270 2 0 {name=p174 sig_type=std_logic lab=Q07}
C {devices/lab_pin.sym} 1170 290 2 0 {name=p175 sig_type=std_logic lab=OUT01}
C {devices/lab_pin.sym} -1090 -440 0 0 {name=p29 sig_type=std_logic lab=OUT01}
C {devices/lab_wire.sym} 110 -640 2 0 {name=p176 sig_type=std_logic lab=ITAIL_SRC}
C {devices/lab_wire.sym} 90 -650 0 0 {name=p177 sig_type=std_logic lab=ITAIL_SINK}
C {devices/lab_pin.sym} -1140 -420 0 0 {name=p38 sig_type=std_logic lab=VSS}
C {7b_divider.sym} -1390 -620 0 0 {name=x18}
C {7b_divider.sym} 860 200 0 0 {name=x17}
C {7b_divider.sym} 1950 210 0 0 {name=x28}
C {Tappered-Buffer_1.sym} -1100 -530 3 0 {name=x13}
C {Tappered-Buffer_1.sym} -100 -840 3 0 {name=x14}
C {Tappered-Buffer_1.sym} 1090 -580 0 0 {name=x15}
C {Tappered-Buffer_1.sym} 1100 -370 0 0 {name=x19}
C {Tappered-Buffer_1.sym} 1130 -560 1 0 {name=x20}
C {Tappered-Buffer_1.sym} -190 -390 1 0 {name=x21}
C {Tappered-Buffer_1.sym} 950 120 1 0 {name=x22}
C {Tappered-Buffer_1.sym} 2190 320 0 0 {name=x23}
C {A_MUX.sym} -870 -750 0 0 {name=x2}
C {A_MUX.sym} -900 -420 0 0 {name=x3}
C {A_MUX.sym} -200 -360 0 0 {name=x4}
C {A_MUX.sym} -170 -890 0 0 {name=x5}
C {A_MUX.sym} 520 -660 0 0 {name=x6}
C {A_MUX.sym} 370 -240 0 0 {name=x12}
C {CP.sym} 70 -540 0 0 {name=x8}
C {VCO_1.sym} 850 -480 0 0 {name=x7}
C {A_MUX.sym} 270 400 0 0 {name=x24}
C {PFD.sym} -480 -600 0 0 {name=x1}
C {devices/lab_wire.sym} -710 -690 2 0 {name=p59 sig_type=std_logic lab=FIN}
C {devices/lab_wire.sym} -700 -420 2 0 {name=p60 sig_type=std_logic lab=FDIV}
C {devices/lab_pin.sym} -1120 -530 2 0 {name=p182 sig_type=std_logic lab=pre_out}
C {devices/lab_wire.sym} 1270 -500 2 0 {name=p183 sig_type=std_logic lab=OUTA1}
C {devices/lab_wire.sym} 1260 -470 2 0 {name=p184 sig_type=std_logic lab=OUTA2}
C {devices/lab_wire.sym} 1550 -600 2 0 {name=p21 sig_type=std_logic lab=OUT}
C {devices/lab_wire.sym} 1550 -390 2 0 {name=p67 sig_type=std_logic lab=OUTB}
C {devices/lab_wire.sym} 1150 -80 2 0 {name=p126 sig_type=std_logic lab=OUT_D}
C {devices/lab_wire.sym} 2660 300 2 0 {name=p150 sig_type=std_logic lab=OUT_CORE}
C {devices/lab_pin.sym} -1120 -970 2 0 {name=p110 sig_type=std_logic lab=PRE_SCALAR}
C {devices/lab_wire.sym} -330 -680 2 0 {name=p180 sig_type=std_logic lab=UP1}
C {devices/lab_wire.sym} -330 -480 1 0 {name=p181 sig_type=std_logic lab=DN1}
C {devices/lab_wire.sym} 530 -340 2 0 {name=p179 sig_type=std_logic lab=MUFTA2}
C {devices/lab_wire.sym} 50 -170 2 0 {name=p178 sig_type=std_logic lab=MUFTA}
C {devices/lab_wire.sym} 90 380 0 0 {name=p16 sig_type=std_logic lab=OUT_D}
C {devices/title.sym} -1710 0 0 0 {name=l1 author="ATIF KHAN"}
C {devices/lab_pin.sym} 1370 -950 0 0 {name=p161 sig_type=std_logic lab=D19}
C {devices/lab_pin.sym} 1350 -930 0 0 {name=p185 sig_type=std_logic lab=D18}
C {devices/lab_pin.sym} 1320 -910 0 0 {name=p186 sig_type=std_logic lab=D17}
C {devices/lab_pin.sym} 1280 -890 0 0 {name=p187 sig_type=std_logic lab=D16}
C {devices/lab_pin.sym} 1260 -870 0 0 {name=p188 sig_type=std_logic lab=OUTB}
C {devices/lab_wire.sym} 1530 -1110 0 0 {name=p189 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1530 -780 2 0 {name=p190 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2140 -950 0 0 {name=p191 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1720 -1020 2 0 {name=p194 sig_type=std_logic lab=p2u}
C {devices/lab_pin.sym} 1740 -1000 2 0 {name=p195 sig_type=std_logic lab=LD1u}
C {devices/lab_pin.sym} 1750 -980 2 0 {name=p196 sig_type=std_logic lab=Q11u}
C {devices/lab_pin.sym} 1770 -960 2 0 {name=p197 sig_type=std_logic lab=Q12u}
C {devices/lab_pin.sym} 1800 -940 2 0 {name=p198 sig_type=std_logic lab=Q13u}
C {devices/lab_pin.sym} 1810 -920 2 0 {name=p199 sig_type=std_logic lab=Q14u}
C {devices/lab_pin.sym} 1840 -900 2 0 {name=p200 sig_type=std_logic lab=Q15u}
C {devices/lab_pin.sym} 1850 -880 2 0 {name=p201 sig_type=std_logic lab=Q16u}
C {devices/lab_pin.sym} 1880 -860 2 0 {name=p202 sig_type=std_logic lab=Q17u}
C {7b_divider.sym} 1580 -930 0 0 {name=x9}
C {Tappered-Buffer_1.sym} 1820 -820 0 0 {name=x10}
C {devices/lab_wire.sym} 2290 -840 2 0 {name=p204 sig_type=std_logic lab=OUT_USB}
C {devices/lab_wire.sym} -1540 -700 0 0 {name=p111 sig_type=std_logic lab=VSS}
C {devices/opin.sym} 800 -790 0 0 {name=p117 lab=OUT_CORE}
C {devices/gnd.sym} 1780 130 1 0 {name=l2 lab=GND}
C {devices/gnd.sym} 1770 150 1 0 {name=l3 lab=GND}
C {devices/gnd.sym} 1770 170 1 0 {name=l4 lab=GND}
C {devices/gnd.sym} 1410 -1010 1 0 {name=l5 lab=GND}
C {devices/gnd.sym} 1410 -970 1 0 {name=l6 lab=GND}
C {devices/gnd.sym} 1420 -990 1 0 {name=l8 lab=GND}
C {devices/lab_wire.sym} 2150 -730 2 0 {name=p36 sig_type=std_logic lab=VSS}
C {Current_Mirror_Top_s.sym} 100 -850 1 0 {name=x11}
C {devices/lab_wire.sym} 130 -1020 0 0 {name=p35 sig_type=std_logic lab=ITAIL}
C {devices/lab_wire.sym} 20 -850 0 0 {name=p120 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 180 -850 2 0 {name=p121 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 510 60 0 0 {name=l7 lab=GND}
C {sky130_fd_pr/cap_mim_m3_2.sym} 520 0 0 0 {name=C3 model=cap_mim_m3_2 W=30 L=30 MF=44 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 340 20 0 0 {name=C4 model=cap_mim_m3_2 W=10 L=10 MF=50 spiceprefix=X}
C {sky130_fd_pr/res_high_po_0p69.sym} 520 -60 0 0 {name=R1
L=110
model=res_high_po_0p69
spiceprefix=X
mult=1}
